# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F102C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: D:\\Keil_v5\\Packs\\ARM\\CMSIS\\6.1.0\\CMSIS\\Core\\Include;D:\Keil_v5\Packs\Keil\STM32F1xx_DFP\2.4.1\Device\Include;D:\Keil_v5\Packs\Keil\STM32F1xx_DFP\2.4.1\Device\StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group User
    ./User/: main.c delay.c delay.h I2C.c I2C.h USART.c USART.h OLED.c OLED.h codetab.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:BKP 3.6.0, Device:StdPeriph Drivers:CAN 3.6.0, Device:StdPeriph Drivers:CEC 3.6.0, Device:StdPeriph Drivers:CRC 3.6.0, Device:StdPeriph Drivers:DAC 3.6.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:FSMC 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:IWDG 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:SDIO 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0, Device:StdPeriph Drivers:WWDG 3.6.0
